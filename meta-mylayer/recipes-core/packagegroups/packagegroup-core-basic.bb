SUMMARY = "Basic minimal package group"
LICENSE = "MIT"

PACKAGES = "${PN}"
RDEPENDS_${PN} = "\
    bash \
    coreutils \
    busybox \
    nano \
"

